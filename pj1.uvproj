# Keil uVision project pj1.uvproj, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARM7 (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM7TDMI)
  output: pj1
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x1000000
  memory RVCT9: RAM 0x20000000 size 0xa0000000
  group Source Group 1
    ./: base.h cnn.c cnn.h func1.c func2_3.c func4_5.c func6.c fixed32_to_uchar.s uchar_to_fixed32.s conv_mul.s make_gray.s relu_active.s
    ./Object/: serial.o startup.o
